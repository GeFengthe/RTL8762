# Keil uVision project group_rcu.uvprojx, settings and files
target group_rcu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DEVICE
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\app\mesh\lib;..\..\..\src\app\mesh\lib\lib;..\..\..\src\app\mesh\lib\platform;..\..\..\src\app\mesh\lib\gap;..\..\..\src\app\mesh\lib\cmd;..\..\..\src\app\mesh\lib\model;..\..\..\src\app\mesh\lib\model\realtek;..\..\..\src\app\mesh\lib\profile;..\..\..\src\app\mesh\lib\utility;..\..\..\src\app\mesh\lib\inc;..\..\..\src\app\mesh\lib\common;..\..\..\src\app\mesh\group_rcu;..\group_rcu;..\..\..\inc\platform;..\..\..\src\app\mesh\group_rcu\key_module;..\..\..\src\app\mesh\group_rcu\bat_module;..\..\..\src\app\mesh\group;..\..\..\src\app\mesh\group_rcu\led_module
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h
  group lib
    ../../../bin/: ROM.lib bee2_sdk.lib gap_utils.lib
    ../../../src/app/mesh/lib/lib/: mesh_dev.lib
    ./../../../bin/: bee2_adc_lib.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_tim.c rtl876x_uart.c rtl876x_gpio.c rtl876x_keyscan.c rtl876x_lpc.c rtl876x_adc.c
  group profile
    ../../../src/app/mesh/lib/profile/: dfu_server.c ota_server.c
  group app
    ../../../src/app/mesh/lib/platform/: reset_watch_dog_timer.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/app/mesh/group_rcu/: app_task.c main.c rcu_app.c rcu_swtimer.c
    ../../../src/app/mesh/lib/common/: mesh_sdk.c
    ../../../src/flash/: silent_dfu_flash.c
  group keyscan
    ../../../src/app/mesh/group_rcu/key_module/: key_handle.c keyscan_driver.c
  group battery
    ../../../src/app/mesh/group_rcu/bat_module/: battery_driver.c
  group led
    ../../../src/app/mesh/group_rcu/led_module/: led_driver.c
  group group_protocol
    ../../../src/app/mesh/group/: group_transmitter.c
