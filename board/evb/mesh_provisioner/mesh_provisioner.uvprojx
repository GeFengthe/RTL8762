# Keil uVision project mesh_provisioner.uvprojx, settings and files
target mesh_provisioner (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_PROVISIONER
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\app\mesh\lib;..\..\..\src\app\mesh\lib\lib;..\..\..\src\app\mesh\lib\platform;..\..\..\src\app\mesh\lib\cmd;..\..\..\src\app\mesh\lib\gap;..\..\..\src\app\mesh\lib\model;..\..\..\src\app\mesh\lib\model\realtek;..\..\..\src\app\mesh\lib\profile;..\..\..\src\app\mesh\lib\utility;..\..\..\src\app\mesh\lib\inc;..\..\..\src\app\mesh\lib\common;..\..\..\src\app\mesh\provisioner;..\mesh_provisioner
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h
  group lib
    ../../../bin/: ROM.lib bee2_sdk.lib gap_utils.lib
    ../../../src/app/mesh/lib/lib/: mesh_prov.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group io
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_uart.c
  group profile
    ../../../src/app/mesh/lib/profile/: dfu_server.c dfu_client.c ota_server.c datatrans_service.c datatrans_client.c
  group model
    ../../../src/app/mesh/lib/model/: configuration_client.c health_client.c generic_on_off_client.c generic_default_transition_time_client.c generic_level_client.c generic_power_on_off_client.c light_lightness_client.c light_hsl_client.c firmware_update_client.c object_transfer_client.c generic_power_level_client.c generic_battery_client.c light_ctl_client.c time_client.c scene_client.c sensor_client.c scheduler_client.c generic_transition_time.c generic_location_client.c generic_property_client.c light_xyl_client.c
    ../../../src/app/mesh/lib/model/realtek/: ping_control.c tp_control.c light_cwrgb_client.c datatrans_model_client.c
  group app
    ../../../src/app/mesh/provisioner/: main.c app_task.c provisioner_app.c provisioner_cmd.c
    ../../../src/app/mesh/lib/common/: mesh_sdk.c ping_app.c generic_client_app.c light_client_app.c dfu_distributor_app.c datatrans_client_app.c
    ../../../src/app/mesh/lib/cmd/: mesh_cmd.c test_cmd.c client_cmd.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/flash/: silent_dfu_flash.c
    ../../../src/app/mesh/lib/model/: delay_msg_rsp.c
