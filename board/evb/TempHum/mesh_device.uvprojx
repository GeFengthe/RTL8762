# Keil uVision project mesh_device.uvprojx, settings and files
target mesh_device (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DEVICE
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\app\mesh\lib;..\..\..\src\app\mesh\lib\lib;..\..\..\src\app\mesh\lib\platform;..\..\..\src\app\mesh\lib\gap;..\..\..\src\app\mesh\lib\cmd;..\..\..\src\app\mesh\lib\model;..\..\..\src\app\mesh\lib\model\realtek;..\..\..\src\app\mesh\lib\profile;..\..\..\src\app\mesh\lib\utility;..\..\..\src\app\mesh\lib\inc;..\..\..\src\app\mesh\lib\common;..\..\..\src\app\mesh\device;.\app;..\nightlight;..\..\..\src\test_model;..\TempHum
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h
  group lib
    ../../../bin/: ROM.lib bee2_sdk.lib gap_bt5.lib bee2_adc_lib.lib gap_utils.lib auto_k_rf.lib auto_k_rf_bonding_lib_DUT.lib
    ../../../src/app/mesh/lib/lib/: mesh_dev.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
  group io
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_uart.c rtl876x_gpio.c rtl876x_tim.c rtl876x_adc.c rtl876x_i2c.c
  group profile
    ../../../src/app/mesh/lib/profile/: dfu_server.c dfu_client.c ota_server.c datatrans_server.c datatrans_service.c
  group model
    ../../../src/app/mesh/lib/model/: health_server.c generic_transition_time.c
    ../../../src/app/mesh/lib/model/realtek/: ping_control.c tp_control.c
  group app
    ./app/: main.c app_task.c device_app.c device_cmd.c app_skyiot_server.c app_skyiot_dlps.c utils_md5.c soft_wdt.c app_hwtmr.c io_management.c
    ../../../src/app/mesh/lib/model/realtek/: datatrans_model_server.c
    ../../../src/app/mesh/lib/common/: datatrans_server_app.c mesh_sdk.c
    ../../../src/app/mesh/lib/cmd/: mesh_cmd.c test_cmd.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/flash/: silent_dfu_flash.c
    ../../../src/app/mesh/lib/model/: delay_msg_rsp.c
    ../../../src/mcu/peripheralSample/I2C/Polling/: i2c_polling_demo.c
  group control
    ./app/: skyswitch.c skyadc.c skyIICdevice.c
  group test_module
    ../../../src/test_model/: data_uart_test.c single_tone.c uart_transport.c
